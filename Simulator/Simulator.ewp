# IAR project Simulator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Libraries/CMSIS/Device/ST/STM32F4xx/Include; ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates; ../Libraries/STM32F4xx_StdPeriph_Driver/inc; DiscoveryLib; RCC; ADC; DAC; UserLibrary; Definitions; VTimers; USART; Serial; ModBusSlave; ModBusMaster; MyTimers; RS232
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Simulator.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Simulator.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c stm32f4xx_conf.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
  group ADC
    ADC/: adc.c adc.h
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group DAC
    DAC/: dac.c dac.h
  group DiscoveryLib
    DiscoveryLib/: stm32f4_discovery.c stm32f4_discovery.h
  group ModBusMaster
    ModBusMaster/: mbmaster.c mbmaster.h
  group ModBusSlave
    ModBusSlave/: mbcrc.c mbcrc.h mbslave.c mbslave.h
  group MyTimers
    MyTimers/: mytim.c mytim.h
  group RCC
    RCC/: rcc.c rcc.h
  group RS232
    RS232/: rs232.c rs232.h
  group SerialCommunication
    Serial/: serial.c serial.h
  group STDPeriph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_adc.h stm32f4xx_crc.h stm32f4xx_dac.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_iwdg.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group UniversalDefinedConstants
    Definitions/: definitions.h initPeripheral.c initPeripheral.h
  group USART
    USART/: usart.c usart.h
  group UserLibrary
    UserLibrary/: userLibrary.c userLibrary.h
  group VTimers
    VTimers/: VTimer.c VTimer.h
