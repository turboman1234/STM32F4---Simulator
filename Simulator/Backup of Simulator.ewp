# IAR project Backup of Simulator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Libraries/CMSIS/Device/ST/STM32F4xx/Include; ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates; ../Libraries/STM32F4xx_StdPeriph_Driver/inc; DiscoveryLib; RCC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Simulator.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Simulator.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c stm32f4xx_conf.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group DiscoveryLib
    DiscoveryLib/: stm32f4_discovery.c stm32f4_discovery.h
  group RCC
    RCC/: rcc.c rcc.h
  group STDPeriph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UniversalDefinedConstants
    Definitions/: definitions.h initPeripheral.c initPeripheral.h
